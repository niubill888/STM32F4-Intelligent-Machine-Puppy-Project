# Keil uVision project new.uvprojx, settings and files
target new (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: new
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\apps;..\libraries\CMSIS\Include;..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\drivers\drv_beep;..\drivers\drv_led;..\drivers\drv_systick;..\drivers\drv_key;..\drivers\drv_exti;..\drivers\drv_fan;..\drivers\drv_motor;..\drivers\drv_usart;..\drivers\drv_timer;..\drivers\drv_esp12f;..\drivers\drv_74hc595;..\drivers\drv_iic;..\drivers\drv_spi2;..\drivers\drv_sht20;..\drivers\drv_sg90;..\drivers\drv_asrpro;..\freertos\Source\include;..\freertos\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group apps
    ../apps/: main.c stm32f4xx_it.c
  group drivers
    ../drivers/drv_systick/: drv_systick.c
    ../drivers/drv_beep/: drv_beep.c
    ../drivers/drv_key/: drv_key.c
    ../drivers/drv_led/: drv_led.c
    ../drivers/drv_exti/: drv_exti.c
    ../drivers/drv_fan/: drv_fan.c
    ../drivers/drv_motor/: drv_motor.c
    ../drivers/drv_timer/: drv_timer.c drv_timer.h
    ../drivers/drv_usart/: drv_usart.c drv_usart.h
    ../drivers/drv_esp12f/: drv_esp12f.c drv_esp12f.h
    ../drivers/drv_74hc595/: 74hc595.c 74hc595.h
    ../drivers/drv_sht20/: drv_sht20.c drv_sht20.h
    ../drivers/drv_spi2/: drv_spi2.c drv_spi2.h
    ../drivers/drv_iic/: drv_iic.c drv_iic.h
    ../drivers/drv_asrpro/: drv_asrpro.c
    ../drivers/drv_sg90/: drv_sg90.h drv_sg90.c
  group cmsis
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group stdlib
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group startup
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group freertos
    ../freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/Source/portable/MemMang/: heap_4.c
    ../freertos/Source/portable/RVDS/ARM_CM4F/: port.c
